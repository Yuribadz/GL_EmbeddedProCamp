# Keil uVision project spidma.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPIDriverWithDMA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Debug\Application\inc;.\Debug\CMSIS\inc;.\Debug\Device;.\Debug\Drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application
    ./Debug/Application/src/: main.c stm32f30x_it.c
  group CMSIS
    ./Debug/CMSIS/scr/: system_stm32f30x.c
  group Drivers
    ./Debug/Drivers/src/: stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_misc.c stm32f30x_tim.c
  group Device
    ./Debug/Device/: startup_stm32f30x.s
